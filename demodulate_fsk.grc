<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demodulate_fsk</value></param>
<param><key>author</key><value>Helio Machado Megías</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Demodulate the given FSK signal.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Demodulate FSK</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>Atcout</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>Input</value></param>
<param><key>label</key><value>In</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>5</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>attack</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>max([mark, space]) + 250</value></param>
<param><key>low_cutoff_freq</key><value>min([mark, space]) - 250</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.05</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decay</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>detect_fsk_tone</key>
<param><key>id</key><value>detect_fsk_mark</value></param>
<param><key>attack</key><value>attack</value></param>
<param><key>baud_rate</key><value>baud_rate</value></param>
<param><key>decay</key><value>decay</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone</key><value>mark</value></param>
</block>
<block>
<key>detect_fsk_tone</key>
<param><key>id</key><value>detect_fsk_space</value></param>
<param><key>attack</key><value>attack</value></param>
<param><key>baud_rate</key><value>baud_rate</value></param>
<param><key>decay</key><value>decay</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tone</key><value>space</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>max([mark, space])+100</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>50</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mark</value></param>
<param><key>value</key><value>2200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>space</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<connection><source_block_id>Input</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>detect_fsk_mark</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>detect_fsk_space</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>Atcout</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detect_fsk_mark</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detect_fsk_space</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
